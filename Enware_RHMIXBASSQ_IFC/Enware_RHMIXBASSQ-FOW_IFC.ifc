Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-08-28T18:09:27+05:30
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels

# IfcFlowTerminal: RHMIXBASSQ-FOW:RHMIXBASSQ-FOW, RHMIXBASSQ-FOW:RHMIXBASSQ-FOW:315465
In: Level 0
Type - Classification: - (Uniformat); Material: Aerator Material (2), Wall Basin Outlet Material, Knob Base Material, Knob Paint Red, Knob Paint Yellow, Knob Paint Blue, Knob Material, Wall Mixer Base Wall Adjustment Material, Wall Mixer Base Material
Type - Pset_ManufacturerTypeInformation - Manufacturer: Enware
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: RHMIXBASSQ-FOW; sets with these values: 2
