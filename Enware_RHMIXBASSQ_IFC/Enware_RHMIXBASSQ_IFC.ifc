Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-08-28T16:58:47+05:30
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: RHMIXBASSQ:RHMIXBASSQ, RHMIXBASSQ:RHMIXBASSQ:706016
In: Level 0
Type - Classification: RHMIXBASSQ-BOW + RHMIXBASSQ-FOW (Uniformat); Material: Aerator Material (2), Wall Basin Outlet Material, Knob Base Material, Knob Paint Red, Knob Paint Yellow, Knob Paint Blue, Knob Material, Wall Mixer Base Wall Adjustment Material, Wall Mixer Base Material, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Enware
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: RHMIXBASSQ; sets with these values: 2
